File: esp32-cellular-shield.sch (KiCad schematic (older format))
At the start: 60 parts, among them J2 CONN_01X05, Q1 Q_NPN_BEC, Q2 Q_NPN_BEC, Q3 Q_NPN_BEC, U1 SIM HOLD - PPSS-6P, U2 SIM800C, U3 Ra-02, U4 MCP601OT, U5 IRLM6402, U6 MCP16311-MNY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

Commit message: add table connect & name pin
Other:
- note removed: "POWER"
Changed lines of the file:
@@
 $EndComp
 $Comp
-L GND #PWR11
+L GND #PWR01
 U 1 1 57DA6B65
 P 3100 1300
-F 0 "#PWR11" H 3100 1050 50  0001 C CNN
+F 0 "#PWR01" H 3100 1050 50  0001 C CNN
 F 1 "GND" H 3105 1127 50  0000 C CNN
 F 2 "" H 3100 1300 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR26
+L GND #PWR02
 U 1 1 57DA6B68
 P 10450 2200
-F 0 "#PWR26" H 10450 1950 50  0001 C CNN
+F 0 "#PWR02" H 10450 1950 50  0001 C CNN
 F 1 "GND" H 10455 2027 50  0000 C CNN
 F 2 "" H 10450 2200 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR28
+L GND #PWR03
 U 1 1 57DA6B94
 P 10450 4375
-F 0 "#PWR28" H 10450 4125 50  0001 C CNN
+F 0 "#PWR03" H 10450 4125 50  0001 C CNN
 F 1 "GND" H 10455 4202 50  0000 C CNN
 F 2 "" H 10450 4375 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD #PWR27
+L VDD #PWR04
 U 1 1 57DA6BAC
 P 10450 3150
-F 0 "#PWR27" H 10450 3000 50  0001 C CNN
+F 0 "#PWR04" H 10450 3000 50  0001 C CNN
 F 1 "VDD" H 10467 3323 50  0000 C CNB
 F 2 "" H 10450 3150 50  0000 C CNN
@@
 NoConn ~ 8100 1700
 $Comp
-L GND #PWR24
+L GND #PWR05
 U 1 1 57DA6BB4
 P 8275 1525
-F 0 "#PWR24" H 8275 1275 50  0001 C CNN
+F 0 "#PWR05" H 8275 1275 50  0001 C CNN
 F 1 "GND" H 8280 1352 50  0000 C CNN
 F 2 "" H 8275 1525 50  0000 C CNN
@@
 NoConn ~ 7925 2100
 $Comp
-L GND #PWR21
+L GND #PWR06
 U 1 1 57DA6BB5
 P 7525 2725
-F 0 "#PWR21" H 7525 2475 50  0001 C CNN
+F 0 "#PWR06" H 7525 2475 50  0001 C CNN
 F 1 "GND" H 7530 2552 50  0000 C CNN
 F 2 "" H 7525 2725 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR25
+L GND #PWR07
 U 1 1 57DA6BB8
 P 8600 2275
-F 0 "#PWR25" H 8600 2025 50  0001 C CNN
+F 0 "#PWR07" H 8600 2025 50  0001 C CNN
 F 1 "GND" H 8605 2102 50  0000 C CNN
 F 2 "" H 8600 2275 50  0000 C CNN
@@
 Text GLabel 4500 2400 1    60   Input ~ 0
 SIM800C_NETLIGHT
-Text Notes 10325 7725 0    157  ~ 31
+Text Notes 5050 9150 0    157  ~ 31
 POWER SUPPLY
 Text Notes 12850 800  0    157  ~ 31
@@
 $EndComp
 $Comp
-L GND #PWR30
+L GND #PWR08
 U 1 1 58A81DF9
 P 10475 6275
-F 0 "#PWR30" H 10475 6025 50  0001 C CNN
+F 0 "#PWR08" H 10475 6025 50  0001 C CNN
 F 1 "GND" H 10480 6102 50  0000 C CNN
 F 2 "" H 10475 6275 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD #PWR29
+L VDD #PWR09
 U 1 1 58A81DFF
 P 10475 5275
-F 0 "#PWR29" H 10475 5125 50  0001 C CNN
+F 0 "#PWR09" H 10475 5125 50  0001 C CNN
 F 1 "VDD" H 10492 5448 50  0000 C CNB
 F 2 "" H 10475 5275 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR18
+L GND #PWR010
 U 1 1 58B19005
 P 4400 4650
-F 0 "#PWR18" H 4400 4400 50  0001 C CNN
+F 0 "#PWR010" H 4400 4400 50  0001 C CNN
 F 1 "GND" H 4405 4477 50  0000 C CNN
 F 2 "" H 4400 4650 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR9
+L GND #PWR011
 U 1 1 58B1DF6A
 P 2950 4800
-F 0 "#PWR9" H 2950 4550 50  0001 C CNN
+F 0 "#PWR011" H 2950 4550 50  0001 C CNN
 F 1 "GND" H 2955 4627 50  0000 C CNN
 F 2 "" H 2950 4800 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR1
+L GND #PWR012
 U 1 1 58B31E00
 P 1150 2650
-F 0 "#PWR1" H 1150 2400 50  0001 C CNN
+F 0 "#PWR012" H 1150 2400 50  0001 C CNN
 F 1 "GND" H 1155 2477 50  0000 C CNN
 F 2 "" H 1150 2650 50  0000 C CNN
@@
 RA_RESET
 $Comp
-L GND #PWR7
+L GND #PWR013
 U 1 1 58BB1771
 P 2825 5600
-F 0 "#PWR7" H 2825 5350 50  0001 C CNN
+F 0 "#PWR013" H 2825 5350 50  0001 C CNN
 F 1 "GND" V 2775 5350 50  0000 C CNN
 F 2 "" H 2825 5600 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR16
+L GND #PWR014
 U 1 1 58BB20C3
 P 3925 5600
-F 0 "#PWR16" H 3925 5350 50  0001 C CNN
+F 0 "#PWR014" H 3925 5350 50  0001 C CNN
 F 1 "GND" V 3925 5400 50  0000 C CNN
 F 2 "" H 3925 5600 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR17
+L GND #PWR015
 U 1 1 58BB21E1
 P 3925 6300
-F 0 "#PWR17" H 3925 6050 50  0001 C CNN
+F 0 "#PWR015" H 3925 6050 50  0001 C CNN
 F 1 "GND" V 3925 6100 50  0000 C CNN
 F 2 "" H 3925 6300 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +3V3 #PWR8
+L +3V3 #PWR016
 U 1 1 58BB2B76
 P 2825 5800
-F 0 "#PWR8" H 2875 5850 50  0001 C CNN
+F 0 "#PWR016" H 2875 5850 50  0001 C CNN
 F 1 "+3V3" V 2840 5928 50  0000 L CNN
 F 2 "" H -4950 -1200 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR37
+L GND #PWR017
 U 1 1 58C464DF
 P 15150 2400
-F 0 "#PWR37" H 15150 2150 50  0001 C CNN
+F 0 "#PWR017" H 15150 2150 50  0001 C CNN
 F 1 "GND" H 15155 2227 50  0000 C CNN
 F 2 "" H 15150 2400 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR12
+L GND #PWR018
 U 1 1 58C3E071
 P 3150 10650
-F 0 "#PWR12" H 3150 10400 50  0001 C CNN
+F 0 "#PWR018" H 3150 10400 50  0001 C CNN
 F 1 "GND" H 3155 10477 50  0000 C CNN
 F 2 "" H 3150 10650 50  0000 C CNN
@@
 Vin
 $Comp
-L +3.3V #PWR3
+L +3.3V #PWR019
 U 1 1 58C3E077
 P 1650 8700
-F 0 "#PWR3" H 1650 8550 50  0001 C CNN
+F 0 "#PWR019" H 1650 8550 50  0001 C CNN
 F 1 "+3.3V" H 1665 8873 50  0000 C CNN
 F 2 "" H 1650 8700 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR5
+L GND #PWR020
 U 1 1 58C3E07B
 P 2150 8950
-F 0 "#PWR5" H 2150 8700 50  0001 C CNN
+F 0 "#PWR020" H 2150 8700 50  0001 C CNN
 F 1 "GND" H 2155 8777 50  0000 C CNN
 F 2 "" H 2150 8950 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR6
+L GND #PWR021
 U 1 1 58C3E07D
 P 2650 8250
-F 0 "#PWR6" H 2650 8000 50  0001 C CNN
+F 0 "#PWR021" H 2650 8000 50  0001 C CNN
 F 1 "GND" H 2655 8077 50  0000 C CNN
 F 2 "" H 2650 8250 50  0000 C CNN
@@
 	-1   0    0    1
 $EndComp
-Text Notes 6400 8850 0    157  ~ 31
-POWER
 $Comp
 L L_Small L1
@@
 $EndComp
 $Comp
-L VDD #PWR19
+L VDD #PWR022
 U 1 1 58C3E509
 P 5350 9900
-F 0 "#PWR19" H 5400 9950 50  0001 C CNN
+F 0 "#PWR022" H 5400 9950 50  0001 C CNN
 F 1 "VDD" H 5367 10073 50  0000 C CNN
 F 2 "" H -1000 325 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +5VD #PWR36
+L +5VD #PWR023
 U 1 1 58C3EE4E
 P 15000 2200
-F 0 "#PWR36" H 15050 2250 50  0001 C CNN
+F 0 "#PWR023" H 15050 2250 50  0001 C CNN
 F 1 "+5VD" H 15015 2373 50  0000 C CNN
 F 2 "" H -375 175 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +5VD #PWR15
+L +5VD #PWR024
 U 1 1 58C3F322
 P 3775 8700
-F 0 "#PWR15" H 3825 8750 50  0001 C CNN
+F 0 "#PWR024" H 3825 8750 50  0001 C CNN
 F 1 "+5VD" H 3790 8873 50  0000 C CNN
 F 2 "" H -11600 6675 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR22
+L GND #PWR025
 U 1 1 58C4271E
 P 7900 10550
-F 0 "#PWR22" H 7900 10300 50  0001 C CNN
+F 0 "#PWR025" H 7900 10300 50  0001 C CNN
 F 1 "GND" H 7905 10377 50  0000 C CNN
 F 2 "" H 7900 10550 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VDD #PWR20
+L VDD #PWR026
 U 1 1 58C435B5
 P 6400 10000
-F 0 "#PWR20" H 6450 10050 50  0001 C CNN
+F 0 "#PWR026" H 6450 10050 50  0001 C CNN
 F 1 "VDD" H 6417 10173 50  0000 C CNN
 F 2 "" H 50  425 50  0001 C CNN
@@
 VDD=4.2V
 $Comp
-L +5VD #PWR4
+L +5VD #PWR027
 U 1 1 58C671AA
 P 2150 8100
-F 0 "#PWR4" H 2200 8150 50  0001 C CNN
+F 0 "#PWR027" H 2200 8150 50  0001 C CNN
 F 1 "+5VD" H 2165 8273 50  0000 C CNN
 F 2 "" H -13225 6075 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +3.3V #PWR23
+L +3.3V #PWR028
 U 1 1 58C67654
 P 8200 9950
-F 0 "#PWR23" H 8250 10000 50  0001 C CNN
+F 0 "#PWR028" H 8250 10000 50  0001 C CNN
 F 1 "+3.3V" H 8215 10123 50  0000 C CNN
 F 2 "" H -50 350 50  0001 C CNN
@@
 	14750 5750 14150 5750
 $Comp
-L GND #PWR38
+L GND #PWR029
 U 1 1 58C9149B
 P 15250 6250
-F 0 "#PWR38" H 15250 6000 50  0001 C CNN
+F 0 "#PWR029" H 15250 6000 50  0001 C CNN
 F 1 "GND" H 15255 6077 50  0000 C CNN
 F 2 "" H 15250 6250 50  0000 C CNN
@@
 5V OUT
 $Comp
-L +5V #PWR13
+L +5V #PWR030
 U 1 1 58C94A58
 P 3300 8250
-F 0 "#PWR13" H 3350 8300 50  0001 C CNN
+F 0 "#PWR030" H 3350 8300 50  0001 C CNN
 F 1 "+5V" H 3315 8423 50  0000 C CNN
 F 2 "" H 0   100 50  0001 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR2
+L +5V #PWR031
 U 1 1 58C953A2
 P 1525 9700
-F 0 "#PWR2" H 1575 9750 50  0001 C CNN
+F 0 "#PWR031" H 1575 9750 50  0001 C CNN
 F 1 "+5V" H 1540 9873 50  0000 C CNN
 F 2 "" H -1775 1550 50  0001 C CNN
@@
 5V OUT
 $Comp
-L VDD #PWR14
+L VDD #PWR032
 U 1 1 58C95F40
 P 3600 1850
-F 0 "#PWR14" H 3650 1900 50  0001 C CNN
+F 0 "#PWR032" H 3650 1900 50  0001 C CNN
 F 1 "VDD" H 3617 2023 50  0000 C CNN
 F 2 "" H -2750 -7725 50  0001 C CNN
@@
 $EndComp
 $Comp
-L VDD #PWR10
+L VDD #PWR033
 U 1 1 58C969B5
 P 3100 750
-F 0 "#PWR10" H 3150 800 50  0001 C CNN
+F 0 "#PWR033" H 3150 800 50  0001 C CNN
 F 1 "VDD" H 3117 923 50  0000 C CNN
 F 2 "" H -3250 -8825 50  0001 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR33
+L GND #PWR034
 U 1 1 58C9AE5D
 P 13800 3750
-F 0 "#PWR33" H 13800 3500 50  0001 C CNN
+F 0 "#PWR034" H 13800 3500 50  0001 C CNN
 F 1 "GND" H 13805 3577 50  0000 C CNN
 F 2 "" H 13800 3750 50  0000 C CNN
@@
 	13800 3600 13800 3750
 $Comp
-L +3.3V #PWR34
+L +3.3V #PWR035
 U 1 1 58C9B32D
 P 14225 3750
-F 0 "#PWR34" H 14275 3800 50  0001 C CNN
+F 0 "#PWR035" H 14275 3800 50  0001 C CNN
 F 1 "+3.3V" H 14240 3923 50  0000 C CNN
 F 2 "" H 5975 -5850 50  0001 C CNN
@@
 NoConn ~ 14150 6150
 $Comp
-L VDD #PWR?
+L VDD #PWR036
 U 1 1 58CA7D0A
 P 14750 5700
-F 0 "#PWR?" H 14800 5750 50  0001 C CNN
+F 0 "#PWR036" H 14800 5750 50  0001 C CNN
 F 1 "VDD" H 14767 5873 50  0000 C CNN
 F 2 "" H 8400 -3875 50  0001 C CNN
