File: esp32-cellular-shield.sch (KiCad schematic (older format))
At the start: 60 parts, among them J2 CONN_01X05, Q1 Q_NPN_BEC, Q2 Q_NPN_BEC, Q3 Q_NPN_BEC, Q4 AO3401_PMOS_GSD, SW1 SW_Push, U1 SIM_HOLDER, U2 SIM800C, U3 Ra-02, U4 MCP601OT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

Commit message: modifypinout sample esp32-uno
Connections:
- net RA_MISO/SPIQ: now also S1.27; no longer S1.30
- net RA_MOSI/SPID: now also S1.26; no longer S1.29
- net RA_RESET: now also S1.25; no longer S1.1
- net RA_SCK: now also S1.28; no longer S1.2
Other:
- note added: "GPIO05"
- note added: "GPIO16\n"
- note added: "GPIO17"
- note added: "GPIO18"
- note added: "GPIO19"
- note added: "GPIO23"
- note removed: "GPIO06\n"
- note removed: "GPIO07\n"
- note removed: "GPIO08\n"
- note removed: "GPIO09\n"
- note removed: "GPIO10\n"
- note removed: "GPIO11\n"
Changed lines of the file:
@@
 NoConn ~ 3775 6100
 NoConn ~ 4150 5700
-Text GLabel 12725 2800 0    60   Input ~ 0
+Text GLabel 12750 2500 0    60   Input ~ 0
 RA_MOSI/SPID
-Text GLabel 12725 2900 0    60   Input ~ 0
+Text GLabel 12750 2600 0    60   Input ~ 0
 RA_MISO/SPIQ
-Text GLabel 14800 2800 2    60   Input ~ 0
+Text GLabel 12750 2700 0    60   Input ~ 0
 RA_SCK
-Text GLabel 14800 2900 2    60   Input ~ 0
+Text GLabel 12750 2400 0    60   Input ~ 0
 RA_RESET
 Text GLabel 3775 5900 2    60   Input ~ 0
@@
 Text GLabel 3775 5800 2    60   Input ~ 0
 RA_MOSI/SPID
-Text Notes 13100 2925 0    39   ~ 0
-GPIO07\n
-Text Notes 13100 2825 0    39   ~ 0
-GPIO08\n
-Text Notes 14250 2825 0    39   ~ 0
-GPIO06\n
 Text Notes 13250 1325 0    39   ~ 0
-GPIO09\n
+GPIO16\n
 Text Notes 13250 1425 0    39   ~ 0
-GPIO10\n
+GPIO17
 Text Notes 13075 1525 0    39   ~ 0
 GPIO02\n
@@
 NoConn ~ 14700 2600
 NoConn ~ 14700 2700
-NoConn ~ 12850 2700
-NoConn ~ 12850 2600
-NoConn ~ 12850 2500
-NoConn ~ 12850 2400
 NoConn ~ 12850 3000
 NoConn ~ 12850 3100
@@
 NoConn ~ 12850 1900
 NoConn ~ 12850 2000
-Text Notes 14250 2925 0    39   ~ 0
-GPIO11\n
 $Comp
 L C_Small C13
@@
 Wire Wire Line
 	2725 5900 2975 5900
-Wire Wire Line
-	12725 2800 12850 2800
-Wire Wire Line
-	12725 2900 12850 2900
-Wire Wire Line
-	14800 2800 14700 2800
-Wire Wire Line
-	14700 2900 14800 2900
 Wire Notes Line
 	6000 5025 6000 6800
@@
 Wire Wire Line
 	13600 3700 13600 3600
+Text GLabel 12550 1200 1    60   Input ~ 0
+GPS_TX
+Text GLabel 12400 1200 1    60   Input ~ 0
+GPS_RX
+Wire Wire Line
+	12550 1200 12550 1300
+Connection ~ 12550 1300
+Wire Wire Line
+	12400 1200 12400 1400
+Connection ~ 12400 1400
+$Comp
+L R_Small R24
+U 1 1 58CA211F
+P 13850 6000
+F 0 "R24" V 13950 6000 50  0000 L CNN
+F 1 "100R" V 13850 5850 50  0000 L CNN
+F 2 "lib:R_0603" H 13850 6000 50  0001 C CNN
+F 3 "" H 13850 6000 50  0000 C CNN
+	1    13850 6000
+	0    -1   -1   0
+$EndComp
+$Comp
+L R_Small R25
+U 1 1 58CA3493
+P 13850 6100
+F 0 "R25" V 13950 6100 50  0000 L CNN
+F 1 "100R" V 13850 5950 50  0000 L CNN
+F 2 "lib:R_0603" H 13850 6100 50  0001 C CNN
+F 3 "" H 13850 6100 50  0000 C CNN
+	1    13850 6100
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	13950 6000 14100 6000
+Wire Wire Line
+	13950 6100 14100 6100
+NoConn ~ 13550 6200
+$Comp
+L VDD #PWR036
+U 1 1 58CA7D0A
+P 14150 5750
+F 0 "#PWR036" H 14200 5800 50  0001 C CNN
+F 1 "VDD" H 14167 5923 50  0000 C CNN
+F 2 "" H 7800 -3825 50  0001 C CNN
+F 3 "" H 7800 -3825 50  0001 C CNN
+	1    14150 5750
+	1    0    0    -1
+$EndComp
+Text Notes 13950 5550 0    60   ~ 0
+VDD=4.2V
+$Comp
+L SIM_HOLDER U1
+U 1 1 58CB5237
+P 7750 1750
+F 0 "U1" H 7750 2162 60  0000 C CNN
+F 1 "SIM_HOLDER" H 7750 2056 60  0000 C CNN
+F 2 "lib:sim_socket_PP" H -375 -275 60  0001 C CNN
+F 3 "" H -375 -275 60  0000 C CNN
+	1    7750 1750
+	1    0    0    -1
+$EndComp
+$Comp
+L Q_PMOS_GSD Q4
+U 1 1 58CB5C4D
+P 3300 8550
+F 0 "Q4" H 3506 8504 50  0000 L CNN
+F 1 "AO3401_PMOS_GSD" H 3506 8595 50  0000 L CNN
+F 2 "lib:SOT-23" H 200 0   50  0001 C CNN
+F 3 "" H 0   -100 50  0001 C CNN
+	1    3300 8550
+	1    0    0    1
+$EndComp
+Wire Wire Line
+	3400 8750 3400 9000
+Wire Wire Line
+	3400 9000 3800 9000
+Wire Wire Line
+	3800 9000 3800 8950
+Text GLabel 12750 2300 0    60   Input ~ 0
+SDA
+Text GLabel 12750 2200 0    60   Input ~ 0
+SCL
+Wire Wire Line
+	12850 2300 12750 2300
+Wire Wire Line
+	12850 2200 12750 2200
+$Comp
+L SW_Push SW1
+U 1 1 58CB69CF
+P 1500 2600
+F 0 "SW1" H 1500 2885 50  0000 C CNN
+F 1 "SW_Push" H 1500 2794 50  0000 C CNN
+F 2 "lib:Tact_switch-4pin" H -1000 400 50  0001 C CNN
+F 3 "" H -1000 400 50  0001 C CNN
+	1    1500 2600
+	1    0    0    -1
+$EndComp
+Text Notes 13200 5200 0    118  ~ 24
+Header GPS NEO
 $Comp
 L ESP-UNO S1
@@
 	-1   0    0    1
 $EndComp
-Text GLabel 12550 1200 1    60   Input ~ 0
-GPS_TX
-Text GLabel 12400 1200 1    60   Input ~ 0
-GPS_RX
-Wire Wire Line
-	12550 1200 12550 1300
-Connection ~ 12550 1300
-Wire Wire Line
-	12400 1200 12400 1400
-Connection ~ 12400 1400
-$Comp
-L R_Small R24
-U 1 1 58CA211F
-P 13850 6000
-F 0 "R24" V 13950 6000 50  0000 L CNN
-F 1 "100R" V 13850 5850 50  0000 L CNN
-F 2 "lib:R_0603" H 13850 6000 50  0001 C CNN
-F 3 "" H 13850 6000 50  0000 C CNN
-	1    13850 6000
-	0    -1   -1   0
-$EndComp
-$Comp
-L R_Small R25
-U 1 1 58CA3493
-P 13850 6100
-F 0 "R25" V 13950 6100 50  0000 L CNN
-F 1 "100R" V 13850 5950 50  0000 L CNN
-F 2 "lib:R_0603" H 13850 6100 50  0001 C CNN
-F 3 "" H 13850 6100 50  0000 C CNN
-	1    13850 6100
-	0    -1   -1   0
-$EndComp
-Wire Wire Line
-	13950 6000 14100 6000
-Wire Wire Line
-	13950 6100 14100 6100
-NoConn ~ 13550 6200
-$Comp
-L VDD #PWR036
-U 1 1 58CA7D0A
-P 14150 5750
-F 0 "#PWR036" H 14200 5800 50  0001 C CNN
-F 1 "VDD" H 14167 5923 50  0000 C CNN
-F 2 "" H 7800 -3825 50  0001 C CNN
-F 3 "" H 7800 -3825 50  0001 C CNN
-	1    14150 5750
-	1    0    0    -1
-$EndComp
-Text Notes 13950 5550 0    60   ~ 0
-VDD=4.2V
-$Comp
-L SIM_HOLDER U1
-U 1 1 58CB5237
-P 7750 1750
-F 0 "U1" H 7750 2162 60  0000 C CNN
-F 1 "SIM_HOLDER" H 7750 2056 60  0000 C CNN
-F 2 "lib:sim_socket_PP" H -375 -275 60  0001 C CNN
-F 3 "" H -375 -275 60  0000 C CNN
-	1    7750 1750
-	1    0    0    -1
-$EndComp
-$Comp
-L Q_PMOS_GSD Q4
-U 1 1 58CB5C4D
-P 3300 8550
-F 0 "Q4" H 3506 8504 50  0000 L CNN
-F 1 "AO3401_PMOS_GSD" H 3506 8595 50  0000 L CNN
-F 2 "lib:SOT-23" H 200 0   50  0001 C CNN
-F 3 "" H 0   -100 50  0001 C CNN
-	1    3300 8550
-	1    0    0    1
-$EndComp
-Wire Wire Line
-	3400 8750 3400 9000
-Wire Wire Line
-	3400 9000 3800 9000
-Wire Wire Line
-	3800 9000 3800 8950
-Text GLabel 12750 2300 0    60   Input ~ 0
-SDA
-Text GLabel 12750 2200 0    60   Input ~ 0
-SCL
-Wire Wire Line
-	12850 2300 12750 2300
-Wire Wire Line
-	12850 2200 12750 2200
-$Comp
-L SW_Push SW1
-U 1 1 58CB69CF
-P 1500 2600
-F 0 "SW1" H 1500 2885 50  0000 C CNN
-F 1 "SW_Push" H 1500 2794 50  0000 C CNN
-F 2 "lib:Tact_switch-4pin" H -1000 400 50  0001 C CNN
-F 3 "" H -1000 400 50  0001 C CNN
-	1    1500 2600
-	1    0    0    -1
-$EndComp
-Text Notes 13200 5200 0    118  ~ 24
-Header GPS NEO
+NoConn ~ 14700 2800
+NoConn ~ 14700 2900
+Text Notes 13075 2425 0    39   ~ 0
+GPIO05
+Text Notes 13075 2525 0    39   ~ 0
+GPIO23
+Text Notes 13075 2625 0    39   ~ 0
+GPIO19
+Text Notes 13075 2725 0    39   ~ 0
+GPIO18
+NoConn ~ 12850 2900
+NoConn ~ 12850 2800
+Wire Wire Line
+	12750 2600 12850 2600
+Wire Wire Line
+	12750 2500 12850 2500
+Wire Wire Line
+	12750 2400 12850 2400
+Wire Wire Line
+	12750 2700 12850 2700
 $EndSCHEMATC

Commit message: add led PWR 4.2V
Parts:
- added D?: Led_PWR, LEDs:LED_0603, symbol LED_Small
- added R?: 470R, lib:R_0603, symbol R_Small
- U1: symbol SIM_HOLDER -> SIM_HOLDER-RESCUE-esp32-cellular-shield
Connections:
- net GND: now also D?.1 (K)
- net VDD: now also R?.1
- new net: D?.2 (A), R?.2
Changed lines of the file:
@@
 Connection ~ 3950 9950
 Wire Wire Line
-	4500 9950 5350 9950
+	4500 9950 5800 9950
 Wire Wire Line
 	4600 9950 4600 10000
@@
 	1900 9800 2850 9800
 Wire Wire Line
-	2000 10600 5350 10600
+	2000 10600 5800 10600
 Wire Wire Line
 	7750 10350 7900 10350
@@
 VDD=4.2V
 $Comp
-L SIM_HOLDER U1
+L SIM_HOLDER-RESCUE-esp32-cellular-shield U1
 U 1 1 58CB5237
 P 7750 1750
@@
 Wire Wire Line
 	12750 2700 12850 2700
+$Comp
+L LED_Small D?
+U 1 1 58FDEB82
+P 5800 10450
+F 0 "D?" H 5800 10685 50  0000 C CNN
+F 1 "Led_PWR" H 5800 10594 50  0000 C CNN
+F 2 "LEDs:LED_0603" V 5800 10450 50  0001 C CNN
+F 3 "" V 5800 10450 50  0000 C CNN
+	1    5800 10450
+	0    -1   -1   0
+$EndComp
+$Comp
+L R_Small R?
+U 1 1 58FDEB88
+P 5800 10200
+F 0 "R?" H 5859 10246 50  0000 L CNN
+F 1 "470R" H 5859 10155 50  0000 L CNN
+F 2 "lib:R_0603" H 5800 10200 50  0001 C CNN
+F 3 "" H 5800 10200 50  0000 C CNN
+	1    5800 10200
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	5800 9950 5800 10100
+Wire Wire Line
+	5800 10300 5800 10350
+Wire Wire Line
+	5800 10600 5800 10550
+Connection ~ 5350 10600
 $EndSCHEMATC

Commit message: modify R20 : 200k to 52.5k-1%, R21: 47k to 12k-1%
Parts:
- R20: value 200k/1% -> 52.5k/1%
- R21: value 47k/1% -> 12k/1%
Other:
- moved on the sheet: C14, C15, D?, R?

Commit message: fix mistake TX, RX GPS to GPIO26 - TX_GPS, GPIO27 - RX_GPS
Connections:
- wire segments 282 -> 221
- no-connect marks 42 -> 40
Other:
- note added: "GPIO26"
- note added: "GPIO27"
Changed lines of the file:
@@
 NoConn ~ 14700 1400
 NoConn ~ 14700 1300
-NoConn ~ 12850 1900
-NoConn ~ 12850 2000
 $Comp
 L C_Small C13
@@
 	10250 2050 10450 2050
 Wire Wire Line
-	10450 1850 10450 2050
-Wire Wire Line
-	10450 2050 10450 2200
+	10450 1850 10450 2200
 Wire Wire Line
 	10450 1250 10450 1450
 Wire Wire Line
-	9800 1650 9950 1650
-Wire Wire Line
-	9950 1650 10150 1650
+	9800 1650 10150 1650
 Wire Wire Line
 	9350 1650 9600 1650
@@
 	7350 1700 7300 1700
 Wire Wire Line
-	3100 750  3100 800
-Wire Wire Line
-	3100 800  3100 900
-Wire Wire Line
-	3100 1100 3100 1200
-Wire Wire Line
-	3100 1200 3100 1300
-Wire Wire Line
-	3100 800  3500 800
-Wire Wire Line
-	3500 800  3850 800
-Wire Wire Line
-	3850 800  4200 800
-Wire Wire Line
-	4200 800  4550 800
+	3100 750  3100 900
+Wire Wire Line
+	3100 1100 3100 1300
+Wire Wire Line
+	3100 800  4550 800
 Wire Wire Line
 	4550 800  4550 900
@@
 	4550 1200 4550 1100
 Wire Wire Line
-	3100 1200 3500 1200
-Wire Wire Line
-	3500 1200 3850 1200
-Wire Wire Line
-	3850 1200 4200 1200
-Wire Wire Line
-	4200 1200 4550 1200
+	3100 1200 4550 1200
 Connection ~ 3100 1200
 Wire Wire Line
@@
 Connection ~ 4200 1200
 Wire Wire Line
-	6225 2700 6575 2700
-Wire Wire Line
-	6575 2700 6925 2700
-Wire Wire Line
-	6925 2700 7525 2700
-Wire Wire Line
-	7525 2700 7725 2700
+	6225 2700 7725 2700
 Wire Wire Line
 	7525 2700 7525 2725
@@
 	2200 3200 1900 3200
 Wire Wire Line
-	10450 4050 10450 4200
-Wire Wire Line
-	10450 4200 10450 4375
-Wire Wire Line
-	10050 3850 10100 3850
-Wire Wire Line
-	10100 3850 10150 3850
+	10450 4050 10450 4375
+Wire Wire Line
+	10050 3850 10150 3850
 Wire Wire Line
 	10100 3900 10100 3850
@@
 	10125 6225 10475 6225
 Wire Wire Line
-	10475 6075 10475 6225
-Wire Wire Line
-	10475 6225 10475 6275
+	10475 6075 10475 6275
 Connection ~ 10475 6225
 Wire Wire Line
-	9875 5875 10125 5875
-Wire Wire Line
-	10125 5875 10175 5875
+	9875 5875 10175 5875
 Connection ~ 10125 5875
 Wire Wire Line
@@
 	7825 2100 7825 1950
 Wire Wire Line
-	8650 1725 8650 1800
-Wire Wire Line
-	8650 1800 8650 1950
-Wire Wire Line
-	8650 1950 8650 2075
+	8650 1725 8650 2075
 Wire Wire Line
 	7825 1950 8650 1950
@@
 	1150 2600 1300 2600
 Wire Wire Line
-	1700 2600 1900 2600
-Wire Wire Line
-	1900 2600 2500 2600
+	1700 2600 2500 2600
 Connection ~ 1900 2600
 Wire Wire Line
@@
 	7350 1600 6225 1600
 Wire Wire Line
-	6225 1500 6225 1600
-Wire Wire Line
-	6225 1600 6225 2075
-Wire Wire Line
-	6225 2075 6225 2300
+	6225 1500 6225 2300
 Wire Wire Line
 	7100 1700 6575 1700
 Wire Wire Line
-	6575 1500 6575 1700
-Wire Wire Line
-	6575 1700 6575 2025
-Wire Wire Line
-	6575 2025 6575 2300
+	6575 1500 6575 2300
 Wire Wire Line
 	6925 1800 6950 1800
 Wire Wire Line
-	6925 1500 6925 1800
-Wire Wire Line
-	6925 1800 6925 1975
-Wire Wire Line
-	6925 1975 6925 2275
+	6925 1500 6925 2275
 Connection ~ 6225 1600
 Connection ~ 6225 2075
@@
 Connection ~ 6925 1800
 Wire Wire Line
-	2825 5600 2925 5600
-Wire Wire Line
-	2925 5600 2975 5600
+	2825 5600 2975 5600
 Wire Wire Line
 	2975 5700 2925 5700
@@
 	4500 2600 4300 2600
 Wire Wire Line
-	2950 4600 2950 4750
-Wire Wire Line
-	2950 4750 2950 4800
-Wire Wire Line
-	2950 4750 3050 4750
-Wire Wire Line
-	3050 4750 3150 4750
-Wire Wire Line
-	3150 4750 3250 4750
-Wire Wire Line
-	3250 4750 3350 4750
-Wire Wire Line
-	3350 4750 3450 4750
-Wire Wire Line
-	3450 4750 3550 4750
-Wire Wire Line
-	3550 4750 3650 4750
-Wire Wire Line
-	3650 4750 3750 4750
-Wire Wire Line
-	3750 4750 3850 4750
+	2950 4600 2950 4800
+Wire Wire Line
+	2950 4750 3850 4750
 Wire Wire Line
 	3850 4750 3850 4600
@@
 	3200 2000 3200 2100
 Wire Wire Line
-	3600 1850 3600 1950
-Wire Wire Line
-	3600 1950 3600 2100
+	3600 1850 3600 2100
 Wire Wire Line
 	3600 1950 3700 1950
@@
 	4300 3800 4400 3800
 Wire Wire Line
-	12125 1300 12550 1300
-Wire Wire Line
-	12550 1300 12850 1300
-Wire Wire Line
-	12125 1400 12400 1400
-Wire Wire Line
-	12400 1400 12850 1400
+	12125 1300 12850 1300
+Wire Wire Line
+	12125 1400 12850 1400
 Wire Wire Line
 	2400 3600 2500 3600
@@
 	12125 1800 12850 1800
 Wire Wire Line
-	14700 2300 14850 2300
-Wire Wire Line
-	14850 2300 15150 2300
+	14700 2300 15150 2300
 Wire Wire Line
 	15150 2300 15150 2400
@@
 	2700 10100 2700 10200
 Wire Wire Line
-	3150 10500 3150 10600
-Wire Wire Line
-	3150 10600 3150 10650
+	3150 10500 3150 10650
 Wire Wire Line
 	3250 10600 3250 10500
@@
 	3700 9900 3700 9950
 Wire Wire Line
-	3700 9950 3950 9950
-Wire Wire Line
-	3950 9950 4300 9950
+	3700 9950 4300 9950
 Wire Wire Line
 	3950 9950 3950 9900
 Connection ~ 3950 9950
 Wire Wire Line
-	4500 9950 4600 9950
-Wire Wire Line
-	4600 9950 5050 9950
-Wire Wire Line
-	5050 9950 5350 9950
-Wire Wire Line
-	5350 9950 5800 9950
+	4500 9950 5800 9950
 Wire Wire Line
 	4600 9950 4600 10000
 Wire Wire Line
-	4600 10200 4600 10250
-Wire Wire Line
-	4600 10250 4600 10350
+	4600 10200 4600 10350
 Wire Wire Line
 	3650 10100 3700 10100
@@
 Connection ~ 3250 10600
 Wire Wire Line
-	5350 9900 5350 9950
-Wire Wire Line
-	5350 9950 5350 10200
+	5350 9900 5350 10200
 Connection ~ 4600 9950
 Wire Wire Line
@@
 Connection ~ 2000 9800
 Wire Wire Line
-	1350 8400 1350 8450
-Wire Wire Line
-	1350 8450 1350 8650
+	1350 8400 1350 8650
 Wire Wire Line
 	1950 8450 1350 8450
@@
 	3400 8250 3400 8350
 Wire Wire Line
-	2150 8100 2150 8200
-Wire Wire Line
-	2150 8200 2150 8250
+	2150 8100 2150 8250
 Wire Wire Line
 	1350 8850 1350 8900
@@
 	1350 8900 2150 8900
 Wire Wire Line
-	2150 8850 2150 8900
-Wire Wire Line
-	2150 8900 2150 8950
+	2150 8850 2150 8950
 Connection ~ 2150 8900
 Wire Wire Line
@@
 	1525 9800 1700 9800
 Wire Wire Line
-	1900 9800 2000 9800
-Wire Wire Line
-	2000 9800 2350 9800
-Wire Wire Line
-	2350 9800 2700 9800
-Wire Wire Line
-	2700 9800 2850 9800
-Wire Wire Line
-	2000 10600 2350 10600
-Wire Wire Line
-	2350 10600 2700 10600
-Wire Wire Line
-	2700 10600 3150 10600
-Wire Wire Line
-	3150 10600 3250 10600
-Wire Wire Line
-	3250 10600 3350 10600
-Wire Wire Line
-	3350 10600 4600 10600
-Wire Wire Line
-	4600 10600 5050 10600
-Wire Wire Line
-	5050 10600 5350 10600
-Wire Wire Line
-	5350 10600 5800 10600
+	1900 9800 2850 9800
+Wire Wire Line
+	2000 10600 5800 10600
 Wire Wire Line
 	7750 10350 7900 10350
 Wire Wire Line
-	7900 10350 7900 10500
-Wire Wire Line
-	7900 10500 7900 10550
+	7900 10350 7900 10550
 Wire Wire Line
 	7750 10150 8200 10150
 Wire Wire Line
-	8200 9950 8200 10150
-Wire Wire Line
-	8200 10150 8200 10250
+	8200 9950 8200 10250
 Wire Wire Line
 	8200 10450 8200 10500
@@
 Wire Wire Line
 	13600 3700 13600 3600
-Text GLabel 12550 1200 1    60   Input ~ 0
+Text GLabel 12700 1900 0    60   Input ~ 0
 GPS_TX
-Text GLabel 12400 1200 1    60   Input ~ 0
+Text GLabel 12700 2000 0    60   Input ~ 0
 GPS_RX
 Wire Wire Line
@@
 	5800 10600 5800 10500
 Connection ~ 5350 10600
+Text Notes 13075 1925 0    39   ~ 0
+GPIO26
+Text Notes 13075 2025 0    39   ~ 0
+GPIO27
+Wire Wire Line
+	12850 1900 12700 1900
+Wire Wire Line
+	12700 2000 12850 2000
 $EndSCHEMATC

Commit message: drop IC PWR 3.3V & swap pin connect to the module
Parts:
- removed ANT1: ANTENNA, lib:coaxial_u.fl-r-smt-1, symbol ANTENNA
- removed C10: 100nF, lib:C_0603, symbol C_Small
- removed C16: 1uF/25V, lib:C_0603, symbol C_Small
- removed Q4: AO3401_PMOS_GSD, lib:SOT-23, symbol Q_PMOS_GSD
- removed R19: 10k, lib:R_0603, symbol R_Small
- removed SW1: SW_Push, lib:Tact_switch-4pin, symbol SW_Push
- removed U1: SIM_HOLDER, lib:sim_socket_PP, symbol SIM_HOLDER-RESCUE-esp32-cellular-shield
- removed U4: MCP601OT, TO_SOT_Packages_SMD:SOT-23-5, symbol MCP601OT
- removed U7: TC1264-3.3VAB, TO_SOT_Packages_SMD:SOT-223-3Lead_TabPin2, symbol TC1264-3.3VAB
- added AE1, AE2: Antenna_Shield, lib:sma_90_r300.124.403, symbol Antenna_Shield
- added U1: SIM_HOLDER, lib:MicroSim-Socket-6P, symbol SIM_HOLDER
- J2: footprint Pin_Headers:Pin_Header_Straight_1x05_Pitch2.54mm -> lib:Pin_Header_NEO6M_GPS_R2_1x05_Pitch2.54mm
- R18: value 10k -> 0R
- gave numbers to parts that had none: 2
Connections:
- net labels removed: +5V, GSM_ANT
- wire segments 221 -> 198
- no-connect marks 40 -> 37
Other:
- note removed: "5V OUT"
- note removed: "5V mạch ESP32"
- note removed: "GPIO02\n"
- note removed: "GPIO04\n"
- note removed: "GPIO05"
- note removed: "GPIO0\n"
- note removed: "GPIO16\n"
- note removed: "GPIO17"
- note removed: "GPIO18"
- note removed: "GPIO19"
- note removed: "GPIO23"
- note removed: "GPIO25\n"
- note removed: "GPIO26"
- note removed: "GPIO27"
- note removed: "Vin ESP32"
- moved on the sheet: C1, C2, C3, C4, C5, C9, D1, R1, R10, R11, R4, R5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
