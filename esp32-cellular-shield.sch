File: esp32-cellular-shield.sch (KiCad schematic (older format))
At the start: 56 parts, among them J2 CONN_01X05, Q1 Q_NPN_BEC, Q2 Q_NPN_BEC, Q3 Q_NPN_BEC, U1 SIM_HOLDER, U2 SIM800C, U3 Ra-02, U6 MCP16311-MNY

Commit message: add header battery
Parts:
- added J1: CONN_01X02, Pin_Headers:Pin_Header_Straight_1x02_Pitch2.00mm, symbol CONN_01X02
Connections:
- net GND: now also J1.2 (P2)
- net VDD: now also J1.1 (P1)
Other:
- note added: "HEADER BAT"
- note added: "LORA"
- note removed: "POWER SUPPLY"
- note removed: "Vin = Vin esp32\nVcc = 5V esp32"
- moved on the sheet: AE1, AE2, C1, C11, C12, C13, C14, C15, C17, C2, C3, C4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
