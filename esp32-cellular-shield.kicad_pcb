# Repository iotmakervn/esp32-cellular-shield

File README.md:

# esp32-cellular-shield
dev: sangseu
- GSM/GPRS : SIM800C

- LORA	 : lora-Ra02

- OLED	 : giống với esp32-wifi-uno

- Nguồn 4.1v : MCP16311, L =Vout/K (K=0.22 V/uH) 
- Nguồn 3.3v : TC1264 (TO-220)

### Schematic

### PCB

### 3D

#### TOP

#### DOWN

### Gerber

[Download](./assets/gerber.zip)

## KiCad design esp32-cellular-shield.kicad_pcb

Parts:
AE1, AE2: Antenna_Shield; sma_90_r300.124.403
C1: 100uF/16v; C_1210
C2: 10uF/16v; C_0603
C3: 33pF/16v; C_0603
C4: 10pF/16v; C_0603
C5: 22pF; C_0603
C6, C8: 33pF; C_0603
C7, C11: 100nF; C_0603
C9: 4.7uF; C_0603
C12, C13: 10uF/50V; C_1210
C14, C15: 10uF/25V; C_1210
C17: 1uF; C_0603
D1: 5.1V/500mA; D_MiniMELF_Standard
D2: SMF05C; SOT-363_SC-70-6
D3, D4: Led_SIM; LED_0603
D5: SS34; do214ac
D6: Led_PWR; LED_0603
J1: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.00mm
J2: CONN_01X05; Pin_Header_NEO6M_GPS_R2_1x05_Pitch2.54mm
L1: 22uH; Choke_SMD_Wuerth-WE-PD2-Typ-MS
Q1, Q2, Q3: Q_NPN_BEC; SOT-23
R1, R18: 0R; R_0603
R2, R6: 4.7k; R_0603
R3, R4, R5: 22R; R_0603
R7, R8, R9, R10, R11: 1K; R_0603
R12, R15: 10K; R_0603
R13, R14, R16, R17: 4k7; R_0603
R20: 52.5k/1%; R_0603
R21: 12k/1%; R_0603
R22: 470R; R_0603
R24, R25: 100R; R_0603
S1: ESP-UNO; ESP-UNO-SH
U1: SIM_HOLDER; MicroSim-Socket-6P
U2: SIM800C
U3: Ra-02; Lora-RA02
U6: MCP16311-MNY; MSOP-8_3x3mm_Pitch0.65mm

Connections:
+5VD: D5.2 (A), S1.5 (5V)
ADC: U2.38 (ADC)
GND: AE1.2 (Shield), AE2.2 (Shield), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, C17.2, D1.2 (A), D2.2, D6.1 (K), J1.2, J2.4, Q1.2 (E), Q2.2 (E), Q3.2 (E), R6.1, R14.2, R17.2, R21.2, S1.6 (GND), S1.7 (GND), S1.35 (GND), U1.5 (GND), U1.8 (GND), U1.9, U1.10, U1.11, U2.8 (GND), U2.13 (GND), U2.19 (GND), U2.21 (GND), U2.27 (GND), U2.30 (GND), U2.31 (GND), U2.33 (GND), U2.36 (GND), U2.37 (GND), U3.2 (GND), U3.9 (GND), U3.16 (GND), U6.5 (Pgnd), U6.8 (Agnd), U6.9 (PAD)
GPS_RX: R24.2, S1.22
GPS_TX: R25.2, S1.21
unnamed: AE1.1 (A), R18.1
unnamed: AE2.1 (A), R1.1
unnamed: C9.1, U2.28 (VRTC)
unnamed: C11.1, U6.7 (BOOST)
unnamed: C11.2, L1.1, U6.6 (SW)
unnamed: C12.1, C13.1, D5.1 (K), U6.3 (EN), U6.4 (Vin)
unnamed: C17.1, U6.2 (Vcc)
unnamed: D3.1 (K), R12.1
unnamed: D4.1 (K), R15.1
unnamed: D6.2 (A), R22.2
unnamed: J2.2, R25.1
unnamed: J2.3, R24.1
unnamed: Q1.1 (B), R2.1, R6.2
unnamed: Q2.1 (B), R13.1, R14.1
unnamed: Q2.3 (C), R12.2
unnamed: Q3.1 (B), R16.1, R17.1
unnamed: Q3.3 (C), R15.2
unnamed: R1.2, U2.32 (GSM_ANT)
unnamed: R3.1, U1.2 (RST)
unnamed: R4.1, U1.3 (CLK)
unnamed: R5.2, U1.7 (Vpp)
unnamed: R7.2, U2.1 (UART1_TXD)
unnamed: R8.2, U2.2 (UART1_RXD)
unnamed: R9.2, U2.5 (UART1_DCD)
unnamed: R10.2, U2.6 (UART1_DTR)
unnamed: R11.2, U2.7 (UART1_RI)
unnamed: R18.2, U3.1 (GND)
unnamed: R20.2, R21.1, U6.1 (Vfb)
PWRKEY: R2.2, S1.28
RA_CS: S1.10 (ADC1), U3.15 (NSS)
RA_MISO/SPIQ: S1.12 (ADC3), U3.13 (MISO)
RA_MOSI/SPID: S1.13 (ADC4), U3.14 (MOSI)
RA_RESET: S1.14 (ADC5), U3.4 (RESET)
RA_SCK: S1.11 (ADC2), U3.12 (SCK)
SCL: S1.23, S1.34 (SCL)
SDA: S1.24, S1.33 (SDA)
SIM800C_CLK: C6.1, D2.4, R4.2, U2.16 (SIM_CLK)
SIM800C_DATA: C5.1, D2.3, R5.1, U2.15 (SIM_DATA)
SIM800C_DCD: R9.1, S1.27
SIM800C_DTR: R10.1, S1.25
SIM800C_NETLIGHT: R13.2, U2.41 (NETLIGHT)
SIM800C_PWRKEY: Q1.3 (C), U2.39 (PWRKEY)
SIM800C_RI: R11.1, S1.26
SIM800C_RST: C8.1, D2.5, R3.2, U2.17 (SIM_RST)
SIM800C_RXD: R8.1, S1.29
SIM800C_STATUS: R16.2, U2.42 (STATUS)
SIM800C_TXD: R7.1, S1.30
SIM800C_VDD: C7.1, D2.6, U1.1 (Vcc), U2.18 (SIM_VDD)
UART2_R: U2.23 (UART2_RXD)
UART2_T: U2.22 (UART2_TXD)
USB_DP: U2.25 (USB_DP)
USB_VBUS: U2.24 (USB_VBUS)
VDD: C1.1, C2.1, C3.1, C4.1, C14.1, C15.1, D1.1 (K), D3.2 (A), D4.2 (A), J1.1, L1.2, R20.1, R22.1, U2.34 (VBAT), U2.35 (VBAT)
Vin: S1.8 (Vin)

Notes on the sheet:
HEADER BAT
ESP_UNO CASE
SIM800C
SIM CARD
LEVEL SHIFTING
VDD=4.2V
Header GPS NEO
LORA

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
Board: 2 copper layers, 68.5 x 53.3 mm, 58 parts (0 on the bottom side), 54 nets.

Other parts of the board:
VAL**: oshw_logo_500; logo5

## Commit log

2017-02-12 add README file
2017-02-12 readme
2017-02-14 started designing schematic
2017-02-14 test ignore
2017-02-14 tets ignore
2017-02-15 complete sch
2017-02-15 add sim800h lib
2017-02-17 clean lib
2017-02-17 add footprint microsim hold
2017-02-18 change wire connect D5's P3 from low site to high site off R20
2017-02-18 edit microsim holder footprint
2017-02-18 reverse two off pin DTR and RI connected with arduino case
2017-02-18 place component
2017-02-18 edge.cuts
2017-02-19 3D model diode,inductor,switch
2017-02-20 add ci
2017-02-20 remove unused file
2017-02-21 replaced components
2017-02-21 wired power supply
2017-02-21 design rules
2017-02-21 wired sim, antena
2017-02-21 completed wiring
2017-02-21 rotated 3D model's D1 180*
2017-02-24 replace sim800L by sim800
2017-02-25 moved sim socket, added SMA connector hold, added logos
2017-02-25 clear ruler, add 3D model SIM800, sim holder
2017-02-26 change design rules, moved via out of footprint, elliptical board egdes
2017-02-26 resized sch size
2017-02-26 swap TX RX, place component name
2017-02-26 pinmap
2017-03-02 modifu name compoment & text, fix track pwr
2017-03-02 update again PCB
2017-03-04 ra-02 component
2017-03-04 ra-02 footprint
2017-03-04 3.3V
2017-03-04 3.3V ???
2017-03-04 connect SPI esp32-iot-uno with Ra-02
2017-03-06 save schematic because update netlit
2017-03-09 add information README, modify line pwr for sim800
2017-03-09 fix mymistake transistor to Q_NPN_BEC
2017-03-09 add esp-uno lib
2017-03-09 modify esp-uno.lib & add footprint esp-uno-shield
2017-03-09 modify .gitignore
2017-03-09 add new lib sim800c
2017-03-10 final connect sim800c
2017-03-11 change value R8 10k to 100k, R9 33.6k to 330k of diagram pwr, resule :3.956V
2017-03-11 change value R8 100k to 20k, R9 330k to 68k of diagram pwr, resule :4.048V
2017-03-11 deleted RESET, SIM800C_RESET
2017-03-11 completed connect sim800C & lora-ra02
2017-03-11 read .net file in pcb
2017-03-11 drop lib unuse
2017-03-11 modify gitignore & del .lib, .cad, .wrl, fb-lib-table
2017-03-11 add PWR 3.3V with IC tc1264-33VAB, swap IC PWR to MCP16311-MNY with Vdd=4.2V
2017-03-13 add PCB
2017-03-15 add header NEO GPS
2017-03-15 add ignore .dcm in .gitignore & final connect PCB
2017-03-16 completed PCB
2017-03-16 add table connect & name pin
2017-03-16 fix link picture PCB in README
2017-03-17 compledted modify PCB - TC1264 change TO-220 to SOT223, Connec SCL, SDA to 21, 22 on PCB
2017-03-17 drop *rescue.lib in gitignore
2017-03-20 change MOSFET irlml6402 to AO3401 30v, 4A & add gerber
2017-03-23 modifypinout sample esp32-uno
2017-03-24 add link download gerber in README file
2017-03-28 update gerber file
2017-04-24 add led PWR 4.2V
2017-04-24 modify R20 : 200k to 52.5k-1%, R21: 47k to 12k-1%
2017-04-25 fix mistake TX, RX GPS to GPIO26 - TX_GPS, GPIO27 - RX_GPS
2017-04-27 drop IC PWR 3.3V & swap pin connect to the module
2017-04-27 compledted connect pcb
2017-04-27 add header battery
2017-04-28 final PCB
